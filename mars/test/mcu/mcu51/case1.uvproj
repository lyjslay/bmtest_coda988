# Keil uVision project case1.uvproj, settings and files
target TargetA (MCS-51)
  device: C8051F000 Silicon Labs
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) CLOCK(20000000)
  output: case1 +hex
  c flags: Optimize=9
  group src
    ./: STARTUP.A51 cvi_mcu51.h test.h chip_cv1822.h putchar.c cvi_mcu51.c config.h case1_main.c test_mailbox.c
    ./driver/: dw_timer.h dw_ictl.h dw_uart.h mailbox.h dw_ictl.c dw_uart.c
